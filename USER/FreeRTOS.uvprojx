# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\HARDWARE\LED;..\HARDWARE\TIMER;..\HARDWARE\LCD;..\HARDWARE\EXTI;..\HARDWARE\KEY;..\TASK\WIFI_Task;..\APP\WIFI;..\HARDWARE\UART4;..\HARDWARE\BEEP;..\TASK\USER_Task;..\APP\USER;..\APP\SENSORS;..\TASK\SENSORS_task;..\APP\WIDGET;..\TASK\ADJUSTMENT_Task;..\HARDWARE\OLED;..\HARDWARE\USART2;..\HARDWARE\TIMER4;..\APP\WIFI;..\HMAC\inc;..\HARDWARE\TIMER2;..\HARDWARE\USART3;..\HARDWARE\TIMER5;..\HARDWARE\TIMER6;..\HARDWARE\ADC;..\HARDWARE\GPIO;..\HARDWARE\SG90;..\HARDWARE\UART5;..\HARDWARE\SPI;..\HARDWARE\RC522
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/TIMER2/: timer2.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/TIMER4/: timer4.c
    ../HARDWARE/TIMER5/: timer5.c
    ../HARDWARE/TIMER6/: timer6.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/UART4/: UART4.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/GPIO/: gpio_init.c gpio.c
    ../HARDWARE/SG90/: sg90.c
    ../HARDWARE/UART5/: uart5.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/RC522/: rc522.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_fsmc.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_dma.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group README
    ../: README.TXT
  group APP
    ../APP/USER/: user.c
    ../APP/SENSORS/: sensors.c
    ../APP/WIDGET/: widget.c
    ../APP/WIFI/: wifi.c mqtt.c
  group TASK
    ../TASK/WIFI_Task/: WIFI_task.c
    ../TASK/USER_Task/: User_task.c
    ../TASK/ADJUSTMENT_Task/: Adjustment_task.c
  group HMAC
    ../HMAC/scr/: utils_hmac.c utils_md5.c utils_sha1.c
  group SENSORS
    ../APP/SENSORS/: dht11.c
